# Repository PubInv/ventmon-ventilator-inline-test-monitor

File README.md:

# VentMon T0.5
The VentMon is an OSHWA certified open source hardware, [US002353](https://certification.oshwa.org/us002353.html)

# VentMon T0.5

Note: The previous version, the VentMon T0.3, has been published in [HardwareX](https://www.sciencedirect.com/science/article/pii/S2468067221000249) with extensive build instructions.

The VentMon T0.5 was roughly designed in June of 2021. This version is self-contained---that is, it will not require a separate computer and internet access.
The inventor team has been especially motivated by the work of Mr. Joe Leier, who repaired ventilators in Guatemala during the pandemic.  Public Invention aims to create a self-contained unit that allows the user to test and repair it in the field.  The device will, however, still be WiFi enabled, and still publish data to a the public data lake.

For now, our ideas and work are published in the directory called [pi](https://github.com/PubInv/ventmon-ventilator-inline-test-monitor/tree/master/pi).

## Configuring the VentMon T0.5 for WiFi

The VentMon is fundamentally a WiFi enabled device which publishes to a public data lake which can be found here:

[\http://ventmon.coslabs.com/rds](http://ventmon.coslabs.com/rds)

In order to configure it, the password and name of the local WiFi networkmust be added via the serial port. To do this, you have to connect to the serial port on the VenMon with a USB cable with a serial monitor. the Arduino IDE has such a serial monitor, but you could use any serial monitor. Then 
simply type the letter "c" and enter to configure the VentMon. Read and follow the instructions to reset and enable or disable the WiFi network.

The Configuration menu may look like this:
```
16:00:17.486 -> Enter 'c' to re-enter this configuration while running.
16:00:17.486 -> WiFi ENABLED
16:00:17.486 -> Enter 'w' to enable WiFi, 'x' to disable WiFi
16:00:17.486 -> Ethernet ENABLED
16:00:17.486 -> Enter 'e' to enable Ethernet, 'f' to disable Ethernet.
16:00:17.486 -> Type the character 'r' to reset wifi ssid and password.
16:00:17.486 -> Type the character 'c' to continue or wait 10 seconds to begin/resume operation:
```

Once you have condifugred it for your local WiFi and verified that you are seeing love traces at the URL above (your trace will likely be near the top, and reflects your loack IP address) then you can power the VentMon which a USB cable which is not monitored by a computer.

# Previous Version VentMon T0.4 - Inline Ventilator Test Fixture and Monitor

March 9th, 2021

The photo above shows the current version of the VentMon, the T0.4 tester/monitor, designed and manufactured by Ben Coombs. We are giving these away free of charge to worthy open source teams.

The VentMon T0.4 improves on the T0.3 because it is self-contained (no cables) and is quite compact. We have also improved the OLED display, although additional firmware changes are coming soon.

The software infrastructure that supports the VentMon, such as [VentDisplay](https://github.com/PubInv/vent-display) and [PIRDS](https://github.com/PubInv/PIRDS-respiration-data-standard), have improved as well.

The VentMon is basically a cloud-enabled [spirometer](https://en.wikipedia.org/wiki/Spirometer) with an FiO2 sensor. When plugged in line to a standard 22mm airway, the device provides
a rich stream of telemetery for: air pressure, air flow, oxygen concentration, humidity, and temperature into a network database.  Engineering teams developing pandemic response ventilators and other respiration tools are the primary users of the VentMon. Additionally, it is completely and transparently open source, so any team can adopt the design and incorporate it into their own devices to provide the same data in an integrated way.

The parts in a VentMon cost about USD$600 in 2023. 

# Usage

## Basics

The VentMon T0.4 can be powered with any micro-USB cable. It has an RJ45 ethernet port, and supports WiFi.  It has a male airway connector and 
a female airway connector in the international standard 22mm adult airway sizes. It comes with an oxygen sensor, which you may have to install
by opening the case. It is not pre-installed because the oxygen sensors have a limited shelf life and some users don't need one. The case can 
be opened with a small jeweler's Phillips head screwdriver.

The VentMon has a small OLED display which gives some startup information and also shows momentary flow and pressure while producing a tiny 
graph of airway pressure. This is not intended for clinical use, but it is useful for letting you know that the device is on and working.

## The Serial Port

The main target for the VentMon project is to support engineers who are working on ventilators and respiration support devices. Most of these engineers will know
how to use the Arudino IDE to see the serial monitor. The baudrate is 500000 (500,000).
A simple human-readable output is printed to the serial port at start up time, which
shows some basic start up information.  After searching for an ethernet connection and WiFi connection, the VentMon will
begin printing dynamic data on the serial port. 
The output is in the [PIRDS data format](https://github.com/PubInv/PIRDS-respiration-data-standard). 
This is useful for verifying that the device is functionally and correctly working.
It is not a good way to analyze data, but you can tell a lot by reviewing this data stream.  However, the preferred way to look at moving interactive waveforms and clinical paramaters is with [VentDisplay](https://github.com/PubInv/vent-display), which requires some configuration.

## Configuring a UDP conncetion

The easiest way to use VentDisplay is to check out our public IoT Data Lake at [http://ventmon.coslabs.com/](http://ventmon.coslabs.com/). 
We name your log file by your IP address. The webpage there looks like this:

These files are sorted by modification timestamp, so if you use one of the methods to place your data there, it will likely be near the top!
The "BreathPlot" links take you to the VentDisplay for that log file, whether it is is static or "live" (that is, being dynamically added to from a
running VentMon.)

By entering a "c" character followed by a newline (probably in the Arduino IDE serial monitor tool), the VentMon will stop sending data 
to the serial port and write out a small menu of instructions. You can follow these instructions to enable or disable either the ethernet
connection, the WiFi connection, or both.  This menu allows you to enter your SSID for your WiFi network and your password, which will be
stored in the EEPROM of the device.

If you choose to use the Ethernet connection, you will probably plug an ethernet CAT5 cable directly into your router and the port on the VentMon.

Both Ethernet and WiFi attempt to send UDP packets to port 6111 at ventmon.coslabs.com.  There our [PIRDS-logger](https://github.com/PubInv/PIRDS-logger)
connection automatically timestamps and logs your UDP packets, and allows them to render for your viewing and analysis pleasure.

## Configuration

Configuring a VentMon T0.4 is a little complicated because we are developing a modular, composable, respiratory ecosystem. The diagrams below try to capture three distinct approaches: using our public data lake (easiest), using Apache (requires understanding httpd.conf and fully understanding all pieces), and a Docker Image (we have not actually created this, but we plan to).

Public Data Lake:

Using Apache:

Public Invention recently created a repo that builds a Docker file image that makes all of this possible locally without running Apache/CGI.
Please visit [PIRDS-docker-local](https://github.com/PubInv/PIRDS-docker-local) for more details. As of March 25th 2021, the Docker system is working 
on one computer (the authors), and another user has reported a problem with it; this is in an early release stage.

## Compiling and updating the Firmware

If you have received a VentMon from us,
it will have VentMonFirmware.ino installed.
The VentMon firmware is a work in progress, and we are making active improvements.
Therefore, you may want to update it from time to time. This requires you to build it with the Arduino IDE on your system.
You are welcome to modify the VentMonFirmware.ino file as needed. To do so, you will
have to install a library of our creation which encpasulates the PIRDS standard.
Copy the libary [pirds_library](https://github.com/PubInv/PIRDS-respiration-data-standard/tree/master/pirds_library) into your Arduino library location. You may need to install the Adafruit BME680 library
and other libraries as well.

Additionally, to compile the version of the firmware, you will need to install the [SFM3X00 library](https://github.com/PubInv/SFM3X00). We wrote this library to encapsulate Sensirion flow sensors of various kinds.

This process is a little clunky; please contact us if you need help with that.

# VentMon 0.3

Note: The important file "breath_plot.html" which renders respiration traces and calculated values from PIRDS 
data was moved to its own [repo](https://github.com/PubInv/vent-display) on Thursday, June 18, 2020.

Since March 16th, I've been working full time on this. Along with volunteers at [EndCornaVirus.org](https://www.endcoronavirus.org/) and [Public Invention](https:\\www.pubinv.org), we have been
[tracking and analyzing](https://github.com/PubInv/covid19-vent-list)
all [open-source ventilator projects]((https://medium.com/@RobertLeeRead/analysis-of-open-source-covid-19-pandemic-ventilator-projects-27acf9075f7e)) we can find. It has become apparent that the biggest piece
they are missing, and the area where Public Invention can most help, is not in designing a new ventilator. Instead, our priority is to build a test/monitoring fixture to assist other teams.

Monitoring and testing are critical for keeping patients alive, and thus we are attempting to
make a combined tester/monitor.

At the moment, this repo is to that end. Our overall strategic plan will give clinicians
enough confidence to actually deploy an open-source ventilator. Our goal is to certify ventilators in a limited, last-resort
sense, in case of a shortfall of commercial and professional equipment. That strategy is discussed later in this document.

Our current process includes rapid high-quality, but also burn-in and multi-day, testing of
ventilators. Perhaps we can produce a benchmark for the [multiple efforts](https://github.com/PubInv/covid19-vent-list) going on right now to develop a
Free-libre Open Source ventilator design.

For further explanation of Public Invetion's design motivation and approach for this project, please refer to the following document -
[Motivation of Strategy](https://github.com/PubInv/ventmon-ventilator-inline-test-monitor/blob/master/Motivation.md)

For a hands on demonstration and in-depth explanation of VentMon, watch our screen cast!  
[VentMon ScreenCast](https://www.youtube.com/watch?v=OV9MrMjVOCI)

# User Manual

Although a work in progress, we have a [user manaul v0.3T](https://github.com/PubInv/ventmon-ventilator-inline-test-monitor/blob/master/doc/UserManaul.md).
This User Manual is basically for the VentMon.

## Design and Dependencies

This project aims to design a standalone inline device plugged into the airway. It will serve the dual purpose of both monitor and alarm when used on an actual patient, and these tests may also produce prototype ventilators that allow for burns.

VentMon depends on the following Arduino library for communication with Sensirion flow sensors: [SFM3X00](https://github.com/PubInv/SFM3x00)

Assembly instructions can be found here: [Assembly Instructions](https://docs.google.com/document/d/1n-Ja3UgbrCLcY8kx9rmTZB7b3yNJ_DnjpA1hwfMbgXk/edit#)

Initial BOM can be found here: [BOM](https://docs.google.com/document/d/1n-Ja3UgbrCLcY8kx9rmTZB7b3yNJ_DnjpA1hwfMbgXk/edit#)

## Status

** October 10th ??year???**

We have now shipped 20 units of the VentMons to open source teams all over the world. Some of them are
using them successfully. We ordered 15 printed circuit boards and 15 3D printed sensor ports, and I built them
by hand. There was an error in the PCBs which is now corrected; I fixed the current them by 
soldering a wire in place. The current design of the case does not perform cable management as well as it should; 
the flow meter cable tends to fall out. We will improve this in future designs.

** August 20th **

We have received 15 populated boards and desigend a 3D printed hat. We are beginning final assembly/manufacture of the 15 units that people have requested to be sent out free-of-charge.

** June 18th ***

Lauria plans to ship 5 more VentMons on the 23rd. She has added FiO2 sensing and important features. Rob Giseburt has create a VentMon-like device using a Raspberry PI; we may switch to that display. The VentMon was used internationally by several teams to gain important insights into their prototype pandemic ventilators. One team may be constructiong their own VentMon from our Open Source designs.

** May 25th **

We have now shipped 4 VentMons. Most recent modifications involved using the "pirds_library" more universally.

** May 7th **

We sent the first VentMon to Artemio Mendoza of the 1MillionVents team, and he made this great video:

**May 4th:**

May the Fourth be with you.

We have shipped two VentMons free of charge to an open source ventilators' team that will use them for volume and flow measurements.

A [user manaul](https://github.com/PubInv/ventmon-ventilator-inline-test-monitor/blob/master/doc/UserManaul.md) is progressing.

**April 27th:**

Assembly instructions can be found here: [Assembly Instructions](https://docs.google.com/document/d/1n-Ja3UgbrCLcY8kx9rmTZB7b3yNJ_DnjpA1hwfMbgXk/edit#)

**April 21st:**

Initial prototype is fully assembled!

**April 20th:**

1) Have a working ESP32 board with pressure sensors and Sensirion flow sensors.
2) This code outputs a stream of PIRDS respiratory standard events on the serial port.
3) These are read by data_server.py which presents a web server for retrieving this data.
4) test_tools/breath_plot.html makes AJAX calls to this server and renders the results dynamically.

## Volunteering

This project is co-led by Robert L. Read <read.robert@gmail.com> and Geoff Mulligan.

Right now we have several needs. People need experience, to have read the [essential reading](https://github.com/PubInv/covid19-vent-list) list, and to have
least 20 hours a week to work with limited supervision.  They must also have the ability to tolerate the chaos
produced by the pandemic and my own mistakes. Finally, they must accept and
hope that the industry will increase ventilation production, and that the disease will be controlled so that this
solution is no longer required.

Right now, we could use:
1. An experienced Arduino engineer to build and improve the design below
1. A JavaScript programmer to add the ability to scroll-through all time to [https://github.com/PubInv/vent-diplay](vent-display) code.
1. Someone to design the User Interface of the "monitor and alarm" feature. They would have to be or become familiar with existing ventilators make a similar interface. This will likely become a small LCD or OLED text screen, 4 physical buttons, and a small speaker or buzzer.

# Request for Donations to Public Invention

[Public Invention](https://www.pubinv.org/) is a small, all-volunteer 501(c)3 US public charity. Your [small donation](https://www.pubinv.org/donate/) is a stamp of approval for our work and will really help us.

# Licensing

All code in this repo is licensed under the GPL License. All documents and diagrams are licensed under CC0. All hardware is licensed under the [CERN Open Hardware Licences Version 2 - Strongly Reciprocal](https://ohwr.org/cern_ohl_s_v2.pdf).

## EAGLE design design/pcb/ventmon_T0.5/ventmon_t0.5i.brd

Parts:
C1, C2: 0.1uF; 0603
C4: 1µF; 0603
IC1: BME280
J6: Header-16; 1X16
J7: Header-12; 1X12
PRESSURE1: HSCDRRT001PD2A3; DIP1330W46P254L1000H616Q8B
R8, R10: 4.7K; 0603
U1: ADS1113IDGST; SOP50P490X110-10N
U$5: JST_GH_4
U$6: JST_GH_6
U$12: JST_GH_2

Connections:
+3V3: C1.1, C2.1, C4.2, IC1.2 (CSB), IC1.6 (VDDIO), IC1.8 (VDD), J6.2, PRESSURE1.2 (VS), R8.1, R10.1, U1.8 (VDD), U$6.6
+5V: J7.3, U$5.4
CS: J6.16, U$6.1
FIO2: U1.4 (AIN0), U$12.2
GND: C1.2, C2.2, C4.1, IC1.1 (GND), IC1.5 (SDO), IC1.7 (GND), J6.4, PRESSURE1.1 (GND), U1.1 (ADDR), U1.3 (GND), U1.5 (AIN1), U$5.3, U$6.5, U$12.1
MISO: J6.13, U$6.2
MOSI: J6.12, U$6.3
SCL: IC1.4 (SCK), J7.11, PRESSURE1.4 (SCL), R8.2, U1.10 (SCL), U$5.2
SCLK: J6.11, U$6.4
SDA: IC1.3 (SDI), J7.12, PRESSURE1.3 (SDA), R10.2, U1.9 (SDA), U$5.1

Notes on the sheet:
For I2C leave CSB pulled high (default value) SDI=SDA, SCK=SCL
Default I²C Address = 0x48
O2 sensors output in the mV range (10-20mV) so this should be amplified. ADS1113 FSR is 2V.
We need 80-100x amplifier like INA333. Would also be nice to convert the single to a differential signal since the oxygen sensor is external, but would have to be part of the plug.
Some Feather boards will also have pull-ups, eg. the OLEDs, so choose one set to use.

Board: 2 copper layers, 22.9 x 50.8 mm, 13 parts (2 on the bottom side), 10 nets.

## EAGLE design design/pcb/ventmon_T0.5/ventmon_t0.5c.brd

Parts:
C18: 1µF; 0603
C19, C21: 0.1uF; C0402_B
D2: 250mA/100V; SOD-323
FIO2: 87438-02
FLOW: 87438-04
IC1: BME280BM280-HAT; BME280-HAT
J6: Header-16; 1X16
J7: Header-12; 1X12
OLED: 87438-04
PRESSURE1: HSCDRRT001PD2A3; DIP1330W46P254L1000H616Q8B
R1, R3: 4.7K; 0603
R4, R5, R7, R9, R15, R16, R18: 10K; 0603
U2: ADS1115IDGST; MSOP10
X1: 87438-03

Connections:
!RESET: D2.A
+3V3: C18.2, C19.2, C21.2, IC1.2 (CSB), IC1.6 (VDD), IC1.8 (VDDIO), J6.2, OLED.2, PRESSURE1.2 (VS), R1.1, R3.1, R5.1, R7.1, R9.1, R15.1, U2.8 (VDD), X1.1
+5V: FLOW.2, J7.3
ADDR: R4.1, U2.1 (ADDR)
ALERT: R5.2, U2.2 (ALERT)
BTNA: J6.16, R16.2, X1.3
BTNB: J6.15, R18.2, X1.2
FIO2: FIO2.2, U2.7 (AIN3)
GND: C18.1, C19.1, C21.1, FIO2.1, FLOW.1, IC1.1 (GND), IC1.5 (SDO), IC1.7 (GND), J6.4, OLED.1, PRESSURE1.1 (GND), R4.2, R16.1, R18.1, U2.3 (GND)
MISO: J6.13
MOSI: J6.12
unnamed: D2.C, J6.1
unnamed: R7.2, U2.6 (AIN2)
unnamed: R9.2, U2.5 (AIN1)
unnamed: R15.2, U2.4 (AIN0)
SCL: FLOW.4, IC1.4 (SCK), J7.11, OLED.4, PRESSURE1.4 (SCL), R1.2, U2.10 (SCL)
SCLK: J6.11
SDA: FLOW.3, IC1.3 (SDI), J7.12, OLED.3, PRESSURE1.3 (SDA), R3.2, U2.9 (SDA)

Notes on the sheet:
Default I²C Address = 1001000
For I2C leave CSB pulled high (default value) SDI=SDA, SCK=SCL

Board: 2 copper layers, 23.2 x 60.6 mm, 22 parts (2 on the bottom side), 14 nets.

## EAGLE design design/pcb/ventmon_T0.4/ventmon_t0.42.brd

Parts:
C1, C2, C3, C4, C5, C6, C9, C10, C17: 0.1uF; C0402_B
C7, C8: 18pF; C0402_B
C11: 100nF; C0402_B
C12, C13: 6.8nF; C0402_B
C14, C26: 10nF; C0402_B
C15: 1n/2KV; C-1808
C16, C22, C23: 0.18uF; 0603
D1: RED; LED-0603
J1: CONN_03; 1X03
J2, J3: CONN_02; 1X02
L2: 3.3µH/±20%/450mA; 0805
R2: 10K; R0402_B
R6: 12.4k 1%; R0402_B
R8: 1M; R0402_B
R10, R11, R13, R14: 49R9 1%; R0402_B
R12: 10R 1%; R0402_B
R17: 0R; R0402_B
R20, R21: 10k; R0402_B
R22, R23: 330R; R0402_B
R24: 1k; R0402_B
R34, R35, R36, R37: 33R; R0402_B
RN1, RN2: 10k; 4X0402ARV341
T1: 7499210121A
U1: W5500
Y1: 25MHz; CRYSTAL-SMD-3.2X2.5MM

Connections:
!INTN: R20.1, U1.36 (INT_N); also elsewhere on the board
!RESET: C10.2, R2.1, U1.37 (RST_N); also elsewhere on the board
+3V3: C9.2, C17.2, C22.1, D1.A, L2.1, R2.2, R20.2, R21.2, RN2.2 (1), RN2.3 (1), RN2.4 (1), T1.11 (LED1_Y+), T1.13 (LED2_G+), U1.28 (VDD); also elsewhere on the board
+3V3A: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C23.1, L2.2, R10.2, R11.2, R12.2, U1.4 (AVDD), U1.8 (AVDD), U1.11 (AVDD), U1.15 (AVDD), U1.17 (AVDD), U1.21 (AVDD)
+5V: J1.1; also elsewhere on the board
ACTLED: R23.2, U1.27 (ACTLED)
CHGND: C15.P$1, T1.Z1 (SHIELD1), T1.Z2 (SHIELD2)
G-: R22.1, T1.14 (LED2_G-)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C14.1, C15.P$2, C16.2, C17.1, C22.2, C23.2, C26.1, J1.2, J1.3, J2.1, J2.2, R6.1, R24.1, RN1.1, RN1.2 (1), RN1.3 (1), RN1.4 (1), RN2.1, U1.3 (AGND), U1.9 (AGND), U1.14 (AGND), U1.16 (AGND), U1.19 (AGND), U1.23 (RSVD), U1.29 (GND), U1.48 (AGND), Y1.2 (3), Y1.4 (3); also elsewhere on the board
LINKLED: R22.2, U1.25 (LINKLED)
MISO: U1.34 (MISO); also elsewhere on the board
MOSI: U1.35 (MOSI); also elsewhere on the board
unnamed: RN2.7 (2), U1.43 (PMODE2)
unnamed: RN2.6 (2), U1.44 (PMODE1)
unnamed: RN2.5 (2), U1.45 (PMODE0)
unnamed: RN1.8 (2), U1.38 (RSVD)
unnamed: RN1.7 (2), U1.39 (RSVD)
unnamed: RN1.6 (2), U1.40 (RSVD)
unnamed: RN1.5 (2), U1.41 (RSVD)
unnamed: RN2.8 (2), U1.42 (RSVD)
unnamed: C8.2, R17.1, Y1.1
unnamed: C16.1, U1.20 (TOCAP)
unnamed: C26.2, U1.22 (1V2O)
unnamed: R6.2, U1.10 (EXRES1)
unnamed: D1.C, R24.2
unnamed: R8.1, R17.2, U1.31 (XO)
unnamed: C7.2, R8.2, U1.30 (XI/CLKIN), Y1.3 (2)
RCT: C14.2, R13.1, R14.1, T1.3 (CRD)
RD+: C12.2, T1.1 (RD+)
RD-: C13.2, T1.2 (RD-)
RX_N: C13.1, R14.2, R37.1
RX_P: C12.1, R13.2, R36.1
R_N: R37.2, U1.5 (RXN)
R_P: R36.2, U1.6 (RXP)
SCLK: U1.33 (SCLK); also elsewhere on the board
SCSN: R21.1, U1.32 (SCS_N); also elsewhere on the board
TCT: C11.2, R12.1, T1.4 (CTD)
TD+: R11.1, R34.1, T1.5 (TD+)
TD-: R10.1, R35.1, T1.6 (TD-)
T_N: R35.2, U1.1 (TXN)
T_P: R34.2, U1.2 (TXP)
V+: J3.2, T1.9 (V+)
V-: J3.1, T1.10 (V-)
Y-: R23.1, T1.12 (LED1_Y-)

Notes on the sheet:
To PoE module
From PoE module

Parts:
C18: 1µF; 0805
C19, C21: 0.1uF; C0402_B
D2: 250mA/100V; SOD-323
FIO2: 87438-02
FLOW: 87438-04
H1, H2, H3, H4: MOUNT-HOLE2.8; 2,8
IC1: BME280BM280-HAT; BME280-HAT
J4: CONN_04POLAR; MOLEX-1X4
J6: Header-16; 1X16
J7: Header-12; 1X12
JP1, JP2, JP3: JUMPER-SMT_2_NC_TRACE_NO-SILK; SMT-JUMPER_2_NC_TRACE_NO-SILK
OLED: 87438-04
PRESSURE1: HSCDRRT001PD2A3; DIP1330W46P254L1000H616Q8B
R1, R3: 4.7K; 0805
R4, R5, R7, R9, R15, R16, R18: 10K; 0805
U2: ADS1115IDGST; MSOP10

Connections:
!INTN: JP2.2; also elsewhere on the board
!RESET: D2.A, JP3.2; also elsewhere on the board
+3V3: C18.2, C19.2, C21.2, IC1.2 (CSB), IC1.6 (VDD), IC1.8 (VDDIO), J4.2, J6.2, OLED.2, PRESSURE1.2 (VS), R1.1, R3.1, R5.1, R7.1, R9.1, R15.1, U2.8 (VDD); also elsewhere on the board
+5V: FLOW.2, J7.3; also elsewhere on the board
ADDR: R4.1, U2.1 (ADDR)
ALERT: R5.2, U2.2 (ALERT)
BTNA: J4.4, J7.4, R18.2
BTNB: J4.3, J7.5, R16.2
FIO2: FIO2.2, U2.7 (AIN3)
GND: C18.1, C19.1, C21.1, FIO2.1, FLOW.1, IC1.1 (GND), IC1.5 (SDO), IC1.7 (GND), J4.1, J6.4, OLED.1, PRESSURE1.1 (GND), R4.2, R16.1, R18.1, U2.3 (GND); also elsewhere on the board
MISO: J6.13; also elsewhere on the board
MOSI: J6.12; also elsewhere on the board
unnamed: D2.C, J6.1
unnamed: J7.7, JP1.1
unnamed: J7.8, JP2.1
unnamed: J7.9, JP3.1
unnamed: R7.2, U2.6 (AIN2)
unnamed: R9.2, U2.5 (AIN1)
unnamed: R15.2, U2.4 (AIN0)
SCL: FLOW.4, IC1.4 (SCK), J7.11, OLED.4, PRESSURE1.4 (SCL), R1.2, U2.10 (SCL)
SCLK: J6.11; also elsewhere on the board
SCSN: JP1.2; also elsewhere on the board
SDA: FLOW.3, IC1.3 (SDI), J7.12, OLED.3, PRESSURE1.3 (SDA), R3.2, U2.9 (SDA)

Notes on the sheet:
Default I²C Address = 1001000
For I2C leave CSB pulled high (default value) SDI=SDA, SCK=SCL

Board: 2 copper layers, 75.0 x 56.1 mm, 77 parts (3 on the bottom side), 58 nets.

## EAGLE design design/pcb/switch_pcb/VentMonSwitches.brd

Parts:
A: 10-XX; B3F-10XX
B: 10-XX; B3F-10XX
H1, H2: MOUNT-HOLE2.8; 2,8
X1: 87438-04

Connections:
3V3: A.1 (S), A.2 (S1), B.1 (S), B.2 (S1), X1.2
BUTTONA: A.3, A.4 (P1), X1.4
BUTTONB: B.3, B.4 (P1), X1.3
GND: X1.1

Board: 2 copper layers, 45.7 x 11.7 mm, 5 parts (0 on the bottom side), 3 nets.

Notices in the files:
parts and their libraries:
SparkFun-Coils: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
Wurth_Signal: Copyright: Würth Elektronik
